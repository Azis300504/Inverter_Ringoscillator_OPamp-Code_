v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 2860 -1210 2890 -1210 {lab=#net1}
N 2860 -1210 2860 -1190 {lab=#net1}
N 2830 -1190 2860 -1190 {lab=#net1}
N 3190 -1190 3210 -1190 {lab=#net2}
N 3210 -1210 3210 -1190 {lab=#net2}
N 3210 -1210 3230 -1210 {lab=#net2}
N 3530 -1190 3580 -1190 {lab=out}
N 3580 -1190 3580 -1110 {lab=out}
N 2470 -1110 3580 -1110 {lab=out}
N 2470 -1210 2470 -1110 {lab=out}
N 2470 -1210 2530 -1210 {lab=out}
N 3530 -1210 3580 -1210 {lab=vdd}
N 3580 -1310 3580 -1210 {lab=vdd}
N 2470 -1310 3580 -1310 {lab=vdd}
N 3530 -1170 3560 -1170 {lab=gnd}
N 3560 -1170 3560 -1070 {lab=gnd}
N 2460 -1070 3560 -1070 {lab=gnd}
N 2830 -1170 2830 -1070 {lab=gnd}
N 3190 -1170 3190 -1070 {lab=gnd}
N 2830 -1310 2830 -1210 {lab=vdd}
N 3190 -1310 3190 -1210 {lab=vdd}
C {untitled.sym} 2680 -1190 0 0 {name=x1
}
C {untitled.sym} 3040 -1190 0 0 {name=x2}
C {untitled.sym} 3380 -1190 0 0 {name=x3}
C {devices/opin.sym} 3570 -1190 0 0 {name=p1 lab=out
}
C {devices/iopin.sym} 2480 -1310 0 1 {name=p2 lab=vdd}
C {devices/iopin.sym} 2470 -1070 0 1 {name=p3 lab=gnd}
